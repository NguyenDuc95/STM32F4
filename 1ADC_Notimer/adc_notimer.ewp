# IAR project adc_notimer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; E:\IAR_Project\ADC\1ADC_Notimer\Libraries\STM32F4xx_StdPeriph_Driver\inc; E:\IAR_Project\ADC\1ADC_Notimer\Libraries\CMSIS\Include; E:\IAR_Project\ADC\1ADC_Notimer\STM32F4-Discovery; E:\IAR_Project\ADC\1ADC_Notimer\Libraries\CMSIS\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
